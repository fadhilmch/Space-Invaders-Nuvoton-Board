# Keil uVision project tubes.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: NUC140VE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.5
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: tubes
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\NUC140BSP_EDU\Library\CMSIS\Include;..\NUC140BSP_EDU\Library\NUC1xx\Include;..\NUC140BSP_EDU\Library\NUC1xx\Source;..\NUC140BSP_EDU\Library\NUC1xx\Include;..\NUC140BSP_EDU\Library\NUC1xx\Source;..\NUC140BSP_EDU\Library\Device\Nuvoton\NUC1xx\Include;..\NUC140BSP_EDU\Library\Device\Nuvoton\NUC1xx\Source;..\NUC140BSP_EDU\Library\NUC1xx-LB_002\Include;..\NUC140BSP_EDU\Library\NUC1xx-LB_002\Source;..\Tubes;C:\Keil_v5\ARM\RL\RTX\Config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group Library Files
    ../NUC140BSP_EDU/Library/CMSIS/Include/: core_cm0.c
    ../NUC140BSP_EDU/Library/NUC1xx/Source/: SPI.c SYS.c GPIO.c I2C.c
    ../NUC140BSP_EDU/Library/NUC1xx-LB_002/Source/: Seven_Segment.c LCD.c Scankey.c EEPROM_24LC64.c
  group Source Files
    ./: main.c
  group CMSIS Files
    ../NUC140BSP_EDU/Library/Device/Nuvoton/NUC1xx/Source/: system_NUC1xx.c
    ./: startup_NUC1xx.s
software components: CMSIS:RTOS:Keil RTX 4.80.0
